# Keil uVision project Sound.uvproj, settings and files
target mbed NXP LPC11U24 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Sound
  AfterMake: fromelf --bin -o build\Sound_LPC11U24.bin build\Sound.axf
  c flags: Optim=1
  c define: TARGET_LPC11U24,  TARGET_M0,  TARGET_NXP,  TARGET_LPC11UXX,  TARGET_LPC11U24_401,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,
  c misc: --gnu
  c include: .;  mbed;  mbed/TARGET_LPC11U24;  mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/LPC11U24.sct
  link misc: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/system_LPC11Uxx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/startup_LPC11xx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
